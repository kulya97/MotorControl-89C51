# Keil uVision project MotorControl.uvproj, settings and files
target Project (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MotorControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\Inc;.\Driver\Inc;.\User
  group User
    ./User/: main.c commond.h
  group Dirver
    ./Driver/Src/: uart.c
